DESCRIPTION = "Freescale Image - Adds Qt5"
LICENSE = "MIT"

require recipes-adv/images/adv-image-qt5-validation-imx.bb
